# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89V51RD2 NXP
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(40000000)
  output: project_hex +hex
  AfterMake: FM COM(3, 9600) DEVICE(89V51RD2, 0.000000, 0) HARDWARE(BOOTEXECRTS, 50, 100) ERASE(DEVICE, PROTECTISP) HEXFILE(D:\ISM_51\project-1\Objects\project_hex.hex, NOCHECKSUMS, NOFILL, PROTECTISP)
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: tes.c
